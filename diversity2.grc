options:
  parameters:
    generate_options: qt_gui
    id: diversity2
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: freq
  id: variable_qtgui_entry
  parameters:
    type: int
    value: '100000000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '500000'
  states: {}
- name: source
  id: variable_qtgui_chooser
  parameters:
    label: Input Source
    label0: Noise Source
    label1: Radio Source
    num_opts: '2'
    option0: '0'
    option1: '1'
    type: int
    value: '0'
    widget: radio_buttons
  states: {}
- name: vec_len
  id: variable
  parameters:
    value: '1024'
  states: {}
- name: volume
  id: variable_qtgui_range
  parameters:
    label: Volume
    start: '0'
    step: '1'
    stop: '100'
    value: '0'
  states: {}
- name: MRC_0
  id: MRC
  parameters: {}
  states: {}
- name: analog_fastnoise_source_x_0
  id: analog_fastnoise_source_x
  parameters:
    amp: '1'
    noise_type: analog.GR_GAUSSIAN
    samples: '8192'
    seed: '0'
    type: complex
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: '20'
    type: complex
  states: {}
- name: blocks_selector_0
  id: blocks_selector
  parameters:
    alias: Source 1
    comment: Source 1 Input
    enabled: 'True'
    input_index: '0'
    num_inputs: '2'
    num_outputs: '1'
    output_index: '0'
    showports: 'False'
    type: complex
  states: {}
- name: blocks_selector_0_0
  id: blocks_selector
  parameters:
    alias: Source 2
    comment: Source 2 Input
    enabled: 'True'
    input_index: '0'
    num_inputs: '2'
    num_outputs: '1'
    output_index: '0'
    showports: 'False'
    type: complex
  states: {}
- name: blocks_var_to_msg_0
  id: blocks_var_to_msg
  parameters:
    msgname: input_source
    target: source
  states: {}
- name: fmsink_0
  id: fmsink
  parameters:
    audio_rate: '44100'
    samp_rate: samp_rate
    volume: volume
  states: {}
- name: phase_match_1
  id: phase_match
  parameters:
    vec_len: vec_len
  states: {}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_VERT
    max: '512'
    name: '"Phase offset"'
    type: short
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: vec_len
    type: complex
  states: {}
- name: soapy_custom_source_0
  id: soapy_custom_source
  parameters:
    antenna0: Tuner 1 50 ohm
    antenna1: Tuner 2 50 ohm
    center_freq0: freq
    center_freq1: freq
    dev_args: remote:driver=sdrplay,mode=DT
    driver: remote
    samp_rate: samp_rate
    type: fc32
  states: {}

connections:
- [MRC_0, '0', fmsink_0, '0']
- [MRC_0, '0', qtgui_sink_x_0, '0']
- [analog_fastnoise_source_x_0, '0', blocks_delay_0, '0']
- [analog_fastnoise_source_x_0, '0', blocks_selector_0_0, '0']
- [blocks_delay_0, '0', blocks_selector_0, '0']
- [blocks_selector_0, '0', MRC_0, '0']
- [blocks_selector_0, '0', phase_match_1, '0']
- [blocks_selector_0_0, '0', phase_match_1, '1']
- [blocks_var_to_msg_0, msgout, blocks_selector_0, iindex]
- [blocks_var_to_msg_0, msgout, blocks_selector_0_0, iindex]
- [phase_match_1, '0', qtgui_number_sink_0, '0']
- [phase_match_1, '1', MRC_0, '1']
- [soapy_custom_source_0, '0', blocks_selector_0, '1']
- [soapy_custom_source_0, '0', blocks_selector_0_0, '1']

metadata:
  file_format: 1
  grc_version: 3.10.5.1
