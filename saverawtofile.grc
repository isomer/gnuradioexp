options:
  parameters:
    author: perry
    generate_options: qt_gui
    id: savetofile
    output_language: python
    title: Save raw samples to file
  states: {}

blocks:
- name: freq
  id: variable_qtgui_entry
  parameters:
    type: int
    value: '100000000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '500000'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /tmp/2020-08-04-100MHz-500kS.cs16
    type: complex
  states: {}
- name: blocks_head_0
  id: blocks_head
  parameters:
    num_items: 2**24
    type: complex
  states: {}
- name: soapy_custom_source_0
  id: soapy_custom_source
  parameters:
    antenna0: Tuner 1 50 ohm
    antenna1: Tuner 2 50 ohm
    center_freq0: freq
    center_freq1: freq
    dev_args: remote:driver=sdrplay,mode=DT
    driver: remote
    samp_rate: samp_rate
    type: fc32
  states: {}

connections:
- [blocks_head_0, '0', blocks_file_sink_0, '0']
- [soapy_custom_source_0, '0', blocks_head_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.5.1
