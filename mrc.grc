options:
  parameters:
    category: '[M7EPL]'
    description: Combines two signals using MRC and with the 2nd and 4th moment to estimate SNR.
    generate_options: hb
    id: MRC
    output_language: python
    title: Maximum Ratio Combining
  states: {}

blocks:
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_add_xx_1
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_divide_xx_0
  id: blocks_divide_xx
  parameters:
    comment: |-
      This adds the signals weighted by their relative SNR, and the
      divide renormalises the signal.
    type: complex
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_multiply_xx_0_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: digital_mpsk_snr_est_cc_0
  id: digital_mpsk_snr_est_cc
  parameters:
    alpha: '0.001'
    comment: |-
      We use the 2nd and 4th moment to estimate SNR, which should work
      even if the signal isn't MPSK.
    tag_nsamples: '10000'
    type: '2'
  states: {}
- name: digital_mpsk_snr_est_cc_0_0
  id: digital_mpsk_snr_est_cc
  parameters:
    alpha: '0.001'
    comment: |-
      We use the 2nd and 4th moment to estimate SNR, which should work
      even if the signal isn't MPSK.
    tag_nsamples: '10000'
    type: '2'
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: out
    type: complex
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: in1
    type: complex
  states: {}
- name: pad_source_1
  id: pad_source
  parameters:
    label: in2
    type: complex
  states: {}

connections:
- [blocks_add_xx_0, '0', blocks_divide_xx_0, '0']
- [blocks_add_xx_1, '0', blocks_divide_xx_0, '1']
- [blocks_divide_xx_0, '0', pad_sink_0, '0']
- [blocks_multiply_xx_0, '0', blocks_add_xx_0, '1']
- [blocks_multiply_xx_0_0, '0', blocks_add_xx_0, '0']
- [digital_mpsk_snr_est_cc_0, '0', blocks_add_xx_1, '0']
- [digital_mpsk_snr_est_cc_0, '0', blocks_multiply_xx_0_0, '1']
- [digital_mpsk_snr_est_cc_0_0, '0', blocks_add_xx_1, '1']
- [digital_mpsk_snr_est_cc_0_0, '0', blocks_multiply_xx_0, '1']
- [pad_source_0, '0', blocks_multiply_xx_0_0, '0']
- [pad_source_0, '0', digital_mpsk_snr_est_cc_0, '0']
- [pad_source_1, '0', blocks_multiply_xx_0, '0']
- [pad_source_1, '0', digital_mpsk_snr_est_cc_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.5.1
