options:
  parameters:
    category: '[M7EPL]'
    description: Changes the phase of "in" to match "ref"
    generate_options: hb
    id: phase_match
    output_language: python
    title: Phase Matcher
  states: {}

blocks:
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    comment: add the phase to all the bins from the fft.
    type: float
    vlen: vec_len
  states: {}
- name: blocks_argmax_xx_1
  id: blocks_argmax_xx
  parameters:
    comment: Select the "bin" with the largest magnitude (the strongest correlation)
    num_inputs: '1'
    type: float
    vlen: vec_len
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters:
    vlen: vec_len
  states: {}
- name: blocks_complex_to_magphase_0
  id: blocks_complex_to_magphase
  parameters:
    vlen: vec_len
  states: {}
- name: blocks_magphase_to_complex_0
  id: blocks_magphase_to_complex
  parameters:
    vlen: vec_len
  states: {}
- name: blocks_multiply_conjugate_cc_0
  id: blocks_multiply_conjugate_cc
  parameters:
    comment: |-
      Multiplying an FFT by the complex conjugate 
      of another FFT then inverting the FFT gives
       you a cross correlation.
    vlen: vec_len
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    comment: Convert from sample index to radians
    const: 2*3.1415926/vec_len
    type: float
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: short
  states: {}
- name: blocks_repeat_0
  id: blocks_repeat
  parameters:
    interp: vec_len
    type: float
  states: {}
- name: blocks_short_to_float_0
  id: blocks_short_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: vec_len
    type: complex
  states: {}
- name: blocks_stream_to_vector_0_0
  id: blocks_stream_to_vector
  parameters:
    num_items: vec_len
    type: complex
  states: {}
- name: blocks_stream_to_vector_1
  id: blocks_stream_to_vector
  parameters:
    num_items: vec_len
    type: float
  states: {}
- name: blocks_vector_to_stream_0
  id: blocks_vector_to_stream
  parameters:
    num_items: vec_len
    type: complex
  states: {}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: vec_len
    forward: 'True'
    shift: 'False'
    type: complex
    window: '[1]*vec_len'
  states: {}
- name: fft_vxx_0_0
  id: fft_vxx
  parameters:
    fft_size: vec_len
    forward: 'True'
    shift: 'False'
    type: complex
    window: '[1]*vec_len'
  states: {}
- name: fft_vxx_1
  id: fft_vxx
  parameters:
    fft_size: vec_len
    forward: 'False'
    shift: 'False'
    type: complex
    window: '[1]*vec_len'
  states: {}
- name: fft_vxx_2
  id: fft_vxx
  parameters:
    fft_size: vec_len
    forward: 'False'
    shift: 'False'
    type: complex
    window: '[1]*vec_len'
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    comment: |-
      This is the offset in samples that the first signal is behind the second.
      Note that this is modulo vec_len, so you often see very large numbers
      here if the second signal lags the first.
    label: offset
    type: short
  states: {}
- name: pad_sink_1
  id: pad_sink
  parameters:
    label: out
    type: complex
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: ref
    type: complex
  states: {}
- name: pad_source_1
  id: pad_source
  parameters:
    label: in
    type: complex
  states: {}
- name: vec_len
  id: parameter
  parameters:
    comment: |-
      Must be a power of 2.
      Larger numbers require substantially more CPU
      Smaller numbers adapt faster
      Must be at least large enough to cover the phase offset between the signals.
    label: Vector Length
    type: intx
    value: '512'
  states: {}

connections:
- [blocks_add_xx_0, '0', blocks_magphase_to_complex_0, '1']
- [blocks_argmax_xx_1, '0', blocks_short_to_float_0, '0']
- [blocks_argmax_xx_1, '0', pad_sink_0, '0']
- [blocks_argmax_xx_1, '1', blocks_null_sink_0, '0']
- [blocks_complex_to_mag_0, '0', blocks_argmax_xx_1, '0']
- [blocks_complex_to_magphase_0, '0', blocks_magphase_to_complex_0, '0']
- [blocks_complex_to_magphase_0, '1', blocks_add_xx_0, '0']
- [blocks_magphase_to_complex_0, '0', fft_vxx_2, '0']
- [blocks_multiply_conjugate_cc_0, '0', fft_vxx_1, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_repeat_0, '0']
- [blocks_repeat_0, '0', blocks_stream_to_vector_1, '0']
- [blocks_short_to_float_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_stream_to_vector_0, '0', fft_vxx_0, '0']
- [blocks_stream_to_vector_0_0, '0', fft_vxx_0_0, '0']
- [blocks_stream_to_vector_1, '0', blocks_add_xx_0, '1']
- [blocks_vector_to_stream_0, '0', pad_sink_1, '0']
- [fft_vxx_0, '0', blocks_multiply_conjugate_cc_0, '0']
- [fft_vxx_0_0, '0', blocks_complex_to_magphase_0, '0']
- [fft_vxx_0_0, '0', blocks_multiply_conjugate_cc_0, '1']
- [fft_vxx_1, '0', blocks_complex_to_mag_0, '0']
- [fft_vxx_2, '0', blocks_vector_to_stream_0, '0']
- [pad_source_0, '0', blocks_stream_to_vector_0, '0']
- [pad_source_1, '0', blocks_stream_to_vector_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.5.1
